# Keil uVision project Template.uvproj, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC230LC2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC230_240\Include;..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group User
    ../: main.c
  group Library
    ../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c can.c adc.c gpio.c timer.c
